# Keil uVision project frame.uvprojx, settings and files
target frame (6220000::V6.22::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: frame +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/ARM/DSP/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Sentry_libs;../Sentry_libs/Algorithm;../Sentry_libs/Algorithm/Chassis_calc;../Sentry_libs/Algorithm/Crc;../Sentry_libs/Algorithm/Kalman;../Sentry_libs/Algorithm/Mahony;../Sentry_libs/Algorithm/Pid;../Sentry_libs/Bsp;../Sentry_libs/Bsp/Can;../Sentry_libs/Bsp/Exti;../Sentry_libs/Bsp/Fdcan;../Sentry_libs/Bsp/I2c;../Sentry_libs/Bsp/Log;../Sentry_libs/Bsp/SPI;../Sentry_libs/Bsp/Tim;../Sentry_libs/Bsp/Uart;../Sentry_libs/Module;../Sentry_libs/Module/BMI088;../Sentry_libs/Module/Buzzer;../Sentry_libs/Module/Com_System;../Sentry_libs/Module/Com_System/assets;../Sentry_libs/Module/Dr16;../Sentry_libs/Module/Ist8310;../Sentry_libs/Module/LED;../Sentry_libs/Module/Minipc;../Sentry_libs/Module/Motor;../Sentry_libs/Module/Motor/Dji;../Sentry_libs/Module/Motor/Dm;../Sentry_libs/Module/Motor/Lk;../Sentry_libs/Module/Motor/Unitree;../Sentry_libs/Module/Servo;../Sentry_libs/pic;../Sentry_libs/temp_informality_InsTask;../Sentry_libs/temp_informality_InsTask/pic;../USB_DEVICE/App;../USB_DEVICE/Target;../../Sentry-Embeded-2026;../Task;../Sentry_libs/Bsp/GPIO;../Sentry_libs/Algorithm/Fliters;../Sentry_libs/Bsp/PWM;../Sentry_libs/Bsp/DWT;../Sentry_libs/Algorithm/Madgwick;../Sentry_libs/Module/Referee;../Sentry_libs/Module/Daemon
  asm include: ../Core/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/ARM/DSP/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Sentry_libs;../Sentry_libs/Algorithm;../Sentry_libs/Algorithm/Chassis_calc;../Sentry_libs/Algorithm/Crc;../Sentry_libs/Algorithm/Kalman;../Sentry_libs/Algorithm/Mahony;../Sentry_libs/Algorithm/Pid;../Sentry_libs/Bsp;../Sentry_libs/Bsp/Can;../Sentry_libs/Bsp/Exti;../Sentry_libs/Bsp/Fdcan;../Sentry_libs/Bsp/I2c;../Sentry_libs/Bsp/Log;../Sentry_libs/Bsp/SPI;../Sentry_libs/Bsp/Tim;../Sentry_libs/Bsp/Uart;../Sentry_libs/Module;../Sentry_libs/Module/BMI088;../Sentry_libs/Module/Buzzer;../Sentry_libs/Module/Com_System;../Sentry_libs/Module/Com_System/assets;../Sentry_libs/Module/Dr16;../Sentry_libs/Module/Ist8310;../Sentry_libs/Module/LED;../Sentry_libs/Module/Minipc;../Sentry_libs/Module/Motor;../Sentry_libs/Module/Motor/Dji;../Sentry_libs/Module/Motor/Dm;../Sentry_libs/Module/Motor/Lk;../Sentry_libs/Module/Motor/Unitree;../Sentry_libs/Module/Servo;../Sentry_libs/pic;../Sentry_libs/temp_informality_InsTask;../Sentry_libs/temp_informality_InsTask/pic;../USB_DEVICE/App;../USB_DEVICE/Target
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Bsp
    ../Sentry_libs/Bsp/Can/: bsp_can.c bsp_can.h README.md
    ../Sentry_libs/Bsp/Fdcan/: bsp_fdcan.c bsp_fdcan.h
    ../Sentry_libs/Bsp/SPI/: bsp_spi.c bsp_spi.h bsp_spi.md
    ../Sentry_libs/Bsp/Uart/: bsp_uart.c bsp_uart.h
    ../Sentry_libs/Bsp/Log/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c bsp_log.c bsp_log.h
    ../Sentry_libs/Bsp/I2c/: bsp_iic.c bsp_iic.h
    ../Sentry_libs/Bsp/PWM/: bsp_pwm.c bsp_pwm.h
    ../Sentry_libs/Bsp/DWT/: bsp_dwt.c bsp_dwt.h
    ../Sentry_libs/Bsp/GPIO/: bsp_gpio.c bsp_gpio.h
    ../Sentry_libs/Module/Buzzer/: music_sheet.c music_sheet.h bsp_buzzer.c bsp_buzzer.h
  group Module
    ../Sentry_libs/Module/Dr16/: dev_dr16.c dev_dr16.h README.md
    ../Sentry_libs/Module/Com_System/: Com_System.c Com_System.h Queue.c Queue.h
    ../Sentry_libs/Module/Motor/Dm/: dev_motor_dm.c dev_motor_dm.h
    ../Sentry_libs/Module/Motor/Dji/: dev_motor_dji.c dev_motor_dji.h
    ../Sentry_libs/Module/BMI088/: dev_bmi088.c dev_bmi088.h
    ../Sentry_libs/Module/Ist8310/: dev_ist_8310.c dev_ist_8310.h
    ../Sentry_libs/Module/Minipc/: dev_minipc.c dev_minipc.h
    ../Sentry_libs/Module/Referee/: dev_referee.c dev_referee.h dev_referee_protocol.h
    ../Sentry_libs/Module/Daemon/: dev_daemon.c dev_daemon.h
  group Task
    ../: robot_config.h
    ../Task/: app_chassis_task.c app_chassis_task.h app_command_task.c app_command_task.h app_ins_task.c app_ins_task.h dev_board_communicate.c dev_board_communicate.h dev_GimbalFollow.c dev_GimbalFollow.h
  group Alg
    ../Sentry_libs/Algorithm/Pid/: alg_pid.c alg_pid.h
    ../Sentry_libs/Algorithm/Chassis_calc/: alg_chassis_calc.c alg_chassis_calc.h alg_chassis_power_control.c alg_chassis_power_control.h
    ../Sentry_libs/Algorithm/Kalman/: alg_kalman.c alg_kalman.h alg_quaternionEKF.c alg_quaternionEKF.h kalman_filter.c kalman_filter.h
    ../Sentry_libs/Algorithm/Fliters/: alg_fliter.c alg_fliter.h
    ../Sentry_libs/Algorithm/Madgwick/: MadgwickAHRS.c MadgwickAHRS.h Fusion_AHRS.cpp Fusion_AHRS.h
    ../Sentry_libs/Algorithm/Crc/: alg_crc.c alg_crc.h
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 6.1.0
